# Keil uVision project first.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: first
  AfterMake: fromelf -cvf .\Objects\first.axf --vhx --8x1 -o image.hex
  AfterMake: fromelf -cvf .\Objects\first.axf -o disasm.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\..\..\AppData\Local\Arm\Packs\ARM\CMSIS\5.9.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: first.c startup.s
